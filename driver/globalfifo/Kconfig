## driver/globalfifo/Kconfig
```kconfig
config GLOBALFIFO
	tristate "Global Fifo Driver"
	default n
	help
	This is a android test deriver.
```
